# Keil uVision project BH-STM32.uvprojx, settings and files
target dht11 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: health +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\ESP8266;..\..\User\Common;..\..\User\Led;..\..\User\nmea_decode\include\nmea;..\..\User\adc;..\..\User\Key;..\..\User\beep;..\..\User\Max30102;..\..\User\Max30205;..\..\User\MQTT\MQTTPacket\src;..\..\User\OLED;..\..\User\SGP30
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/usart/: bsp_usart.c
    ../../User/dwt_delay/: core_delay.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/ESP8266/: bsp_esp8266.c
    ../../User/Common/: Common.c
    ../../User/Led/: bsp_led.c
    ../../User/dht11/: bsp_dht11.c
    ../../User/SGP30/: sgp30.c
  group MQTT
    ../../User/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
